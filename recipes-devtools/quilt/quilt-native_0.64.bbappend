
# add this because /bin/date and /bin/getopt on BSD are different
EXTRA_OECONF += " --without-date --without-getopt "